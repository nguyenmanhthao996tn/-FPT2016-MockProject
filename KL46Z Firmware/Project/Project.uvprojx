# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: MKL46Z256xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.4.0
  cpu: IRAM(0x1FFFE000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group Source Group 1
    ./: myLeds.c myPIT.c myUART0.c myLeds.h myPIT.h myUART0.h main.c myConnection.h myConnection.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
